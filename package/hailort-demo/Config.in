## package/hailort-demo/Config.in
```kconfig
config BR2_PACKAGE_HAILORT_DEMO
    bool "hailo demo"
    help
      Build and install Hailo demo.
```
